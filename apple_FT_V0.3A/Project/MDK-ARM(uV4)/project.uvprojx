# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\User\FatFS\src;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\User\usbd_mass_storage;..\..\User\ft_support;..\..\User\test;..\..\User\emenu;..\..\User\chip_ft;..\..\User\lwrb;..\..\User\easylogger\inc;..\..\User\easylogger\plugins\file;..\..\User\LOG;..\..\User\MultiButton-1.1.0;..\..\User\cm_backtrace;..\..\User\MultiTimer
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000008 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CmBacktrace
    ../../User/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h cmb_app.c
    ../../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group User
    ../../User/: main.c demo_sdio_fatfs.c lcd.c demo_i2c_eeprom.c demo_spi_flash.c debug.c CRC_Code.c TODO.txt key.c demo_spi_flash_fatfs.c eeprom.c flash_fatfs.c board_data_format.c board_type.c btldr_config.h udisk_task.c
  group ft
    ../../User/chip_ft/: __test_config.h __otp_type.h __chip_reg.h __test_common.c __test_common.h __test_return_info.h __test_return_type.h __test_standard.h __xor_default.h chip_info.h chip_type.h crc32.c ee_data.c test_binning.c test_interface_power.c chip_bus.c chip_access.c test.c test_handshark.c test_pmu.c test_cmu.c test_otp.c test_ram.c test_spl.c test_qc.c test_current.c run_mode_info.c dut.c spt5113c_firmware.h
  group LOG
    ../../User/LOG/: log.c log.h
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_timer.c bsp_uart_fifo.c bsp_lcd_st7789.c bsp_key.c bsp_sdio_sd.c bsp_spi_bus.c bsp_spi_flash.c bsp_eeprom_24xx.c bsp_i2c_gpio.c bsp_beep.c bsp_rtc.c bsp_led.c bsp_prog_robot_comm.c bsp_adc_dma.c bsp_timer_capture.c bsp_ch440r.c bsp_ch440r_ex.c bsp_socket.c bsp_hp_osc.c bsp_iwdg.c bsp_apple_asu.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c stm32f4xx_assert.c bsp.c bsp.h
  group Doc
    ../../Doc/: 02.修改记录.txt 03.开发环境说明.txt
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_dac.c stm32f4xx_iwdg.c stm32f4xx_crc.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group lwrb
    ../../User/lwrb/: lwrb.c
  group FatFS
    ../../User/FatFS/src/: ff.c diskio.c
    ../../User/FatFS/: FatFS移植记录.txt
    ../../User/FatFS/src/option/: cc936.c
  group USB_Device_Library
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USBD MassStorage
    ../../User/usbd_mass_storage/: usbd_usr.c usb_bsp.c usb_it.c usbd_desc.c usbd_storage_msd.c
  group USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group multi_button
    ../../User/MultiButton-1.1.0/: multi_button.c multi_button.h
  group multi_timer
    ../../User/MultiTimer/: MultiTimer.c MultiTimer.h
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\User\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.6.0
